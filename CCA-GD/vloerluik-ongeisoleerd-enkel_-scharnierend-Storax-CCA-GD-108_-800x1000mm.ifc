Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 5cb78e33-dd7f-4712-9b87-cf638d54fc87.ifc
Time: 2026-08-11T15:16:36
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - CCA-GD 108, 800x1000mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAGGNEKcFAAAAV-sCAAV2SgAA2FMBAInDAABZ7AIAq-wCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAGGNEKcFAAAAV-sCAAV2SgAA2FMBAInDAABZ7AIAq-wCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 21 kg/st; STABU2: 43.31.10; dagmaatlengte: 800 mm; lengte: 940 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 1120 mm; serie: CCA-GD; afsluitbaar: True; hoogte: 76,5 mm; merk: Storax; breuklast: A15; type: 108; dagmaatbreedte: 1000 mm; omranding: aluminium; luik: aluminium; aandrijving: Storax - gasdrukveer
