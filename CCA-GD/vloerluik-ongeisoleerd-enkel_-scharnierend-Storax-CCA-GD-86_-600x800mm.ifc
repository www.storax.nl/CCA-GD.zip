Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: b432793e-86c2-4767-ade8-def8ec1c5daa.ifc
Time: 2026-08-11T15:15:31
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - CCA-GD 86, 600x800mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAGG7FqcFAAAAV-sCAAV2SgAA2FMBAInDAABZ7AIAneoCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAGG7FqcFAAAAV-sCAAV2SgAA2FMBAInDAABZ7AIAneoCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 15 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 740 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 920 mm; serie: CCA-GD; afsluitbaar: True; hoogte: 76,5 mm; merk: Storax; breuklast: A15; type: 86; dagmaatbreedte: 800 mm; omranding: aluminium; luik: aluminium; aandrijving: Storax - gasdrukveer
