Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 2a8a0e5b-e28d-49cc-b4fb-164e7e6905bd.ifc
Time: 2026-08-11T15:15:19
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - CCA-GD 66, 600x600mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAGHQFqcFAAAAV-sCAAV2SgAA2FMBAInDAABZ7AIA9uoCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAGHQFqcFAAAAV-sCAAV2SgAA2FMBAInDAABZ7AIA9uoCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 13 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 740 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 720 mm; serie: CCA-GD; afsluitbaar: True; hoogte: 76,5 mm; merk: Storax; breuklast: A15; type: 66; dagmaatbreedte: 600 mm; omranding: aluminium; luik: aluminium; aandrijving: Storax - gasdrukveer
