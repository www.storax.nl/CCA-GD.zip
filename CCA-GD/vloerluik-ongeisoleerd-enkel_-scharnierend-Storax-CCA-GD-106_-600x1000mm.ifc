Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 1502602f-f608-4c32-8101-3a4e74dd476a.ifc
Time: 2026-08-11T15:16:11
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - CCA-GD 106, 600x1000mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAGEfF6cFAAAAV-sCAAV2SgAA2FMBAInDAABZ7AIAOesCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); Hyperlink: https://bcb-online.nl/?WUID=AgAAAGEfF6cFAAAAV-sCAAV2SgAA2FMBAInDAABZ7AIAOesCAAMA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEsFAQEAAAADAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAAQmoAAAVg3wAAZDAAAManAACjrQAA6dgAAAAASw0CAAVqJgAA_y0AALtzAABMDQIAYg0CAAEAEAABAQAAAAQAAADvrgAABXC5AABkMAAAxqcAAKOtAADp2AAAAAA); gewicht per st: 18 kg/st; STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 740 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 1120 mm; serie: CCA-GD; afsluitbaar: True; hoogte: 76,5 mm; merk: Storax; breuklast: A15; type: 106; dagmaatbreedte: 1000 mm; omranding: aluminium; luik: aluminium; aandrijving: Storax - gasdrukveer
